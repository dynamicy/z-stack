# IAR project ZIGBEE Device.ewp, settings and files
configuration EndDeviceEB_M140 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: LCD_SUPPORTED=DEBUG; NWK_AUTO_POLL; ZTOOL_P1; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_TASK; xPOWER_SAVING; xNV_RESTORE; End_Device; M140; HAL_KEYPAD; xPA2591
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\MODULE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530EB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: ..\..\..\Tools\CC2530DB\f8w2530.xcl
configuration EndDeviceEB_M200 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; End_Device; M200; xPA2591
configuration EndDeviceKB_M140 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; End_Device; M140; xPA2591
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\MODULE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530KB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
configuration EndDeviceKB_M200 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; End_Device; xPA2591; M200
  ICC8051.CCIncludePath2: as above
configuration EndDeviceEB_RS232 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LCD_SUPPORTED=DEBUG; NWK_AUTO_POLL; ZTOOL_P1; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_TASK; xPOWER_SAVING; xNV_RESTORE; End_Device; xHAL_KEYPAD; xPA2591
configuration EndDeviceKB_RS232 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; End_Device; xPA2591
  ICC8051.CCIncludePath2: as above
configuration EndDeviceNB_RS232 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_TASK; xPOWER_SAVING; xNV_RESTORE; End_Device; xPA2591
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\SOURCE; ..\..\SOURCE; ..\..\..\ZMAIN\TI2530DB; ..\..\..\..\..\COMPONENTS\MT; ..\..\..\..\..\COMPONENTS\HAL\INCLUDE; ..\..\..\..\..\COMPONENTS\HAL\MODULE; ..\..\..\..\..\COMPONENTS\HAL\TARGET\CC2530NB; ..\..\..\..\..\COMPONENTS\OSAL\MCU\CCSOC; ..\..\..\..\..\COMPONENTS\OSAL\INCLUDE; ..\..\..\..\..\COMPONENTS\STACK\AF; ..\..\..\..\..\COMPONENTS\STACK\NWK; ..\..\..\..\..\COMPONENTS\STACK\SEC; ..\..\..\..\..\COMPONENTS\STACK\SAPI; ..\..\..\..\..\COMPONENTS\STACK\SYS; ..\..\..\..\..\COMPONENTS\STACK\ZCL; ..\..\..\..\..\COMPONENTS\STACK\ZDO; ..\..\..\..\..\COMPONENTS\ZMAC\F8W; ..\..\..\..\..\COMPONENTS\ZMAC; ..\..\..\..\..\COMPONENTS\SERVICES\SADDR; ..\..\..\..\..\COMPONENTS\SERVICES\SDATA; ..\..\..\..\..\COMPONENTS\MAC\INCLUDE; ..\..\..\..\..\COMPONENTS\MAC\HIGH_LEVEL; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04; ..\..\..\..\..\COMPONENTS\MAC\LOW_LEVEL\srf04\SINGLE_CHIP
configuration EndDeviceEB_M220 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LCD_SUPPORTED=DEBUG; NWK_AUTO_POLL; ZTOOL_P1; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_TASK; xPOWER_SAVING; xNV_RESTORE; End_Device; M220; xHAL_KEYPAD; xPA2591
configuration EndDeviceKB_M220 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; End_Device; M220; xPA2591
  ICC8051.CCIncludePath2: as above
configuration EndDeviceEB_M310 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: LCD_SUPPORTED=DEBUG; NWK_AUTO_POLL; ZTOOL_P1; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; MT_TASK; xPOWER_SAVING; xNV_RESTORE; End_Device; M310; xHAL_KEYPAD; xPA2591
configuration RouterDeviceKB_M140 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; Router_Device; M140; xPA2591
  ICC8051.CCIncludePath2: as above
configuration RouterDeviceKB_M200 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
  ICC8051.CCIncludePath2: as above
configuration RouterDeviceEB_M220 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
configuration RouterDeviceEB_M310 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: as above
configuration EndDeviceEB_M160 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; End_Device; HAL_KEYPAD; xPA2591; MMN_UART
configuration EndDeviceEB_M270 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: NWK_AUTO_POLL; ZTOOL_P1; MT_TASK; MT_APP_FUNC; MT_SYS_FUNC; MT_ZDO_FUNC; LCD_SUPPORTED=DEBUG; xPOWER_SAVING; End_Device; HAL_KEYPAD; M270; xPA2591
  group App
    ../Source/: hal_sensor.c hal_sensor.h OSAL_ZIGBEE Device.c zcl_zigbee device.c zcl_zigbee device.h zcl_zigbee device_data.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_buzzer.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_keypad.h hal_lcd.h hal_led.h hal_rs485.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Modules
    ../../../../../Components/hal/target/CC2530NB/: hal_relay.c hal_relay.h hal_rtc.c hal_rtc.h
    ../../../../../Components/hal/module/: M110.c M140.c M140.h M160.c M160.h M170.c M170.h M190.c M190.h M200.c M200.h M220.c M220.h M270.c M310.c M310.h
    ../../../../../COMPONENTS/hal/module/: M110.h M270.h
  group HAL/Target/CC2530EB/Config
    ../../../../../Components/hal/target/CC2530EB/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../../../../../Components/hal/target/CC2530EB/: hal_adc.c hal_buzzer.c hal_dma.c hal_flash.c hal_key.c hal_keypad.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530EB/Includes
    ../../../../../Components/hal/target/CC2530EB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2530KB/Config
    ../../../../../Components/hal/target/CC2530KB/: hal_board_cfg.h
  group HAL/Target/CC2530KB/Drivers
    ../../../../../Components/hal/target/CC2530KB/: hal_adc.c hal_buzzer.c hal_dma.c hal_flash.c hal_key.c hal_keypad.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530KB/Includes
    ../../../../../Components/hal/target/CC2530KB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2530NB/Config
    ../../../../../Components/hal/target/CC2530NB/: hal_board_cfg.h
  group HAL/Target/CC2530NB/Drivers
    ../../../../../Components/hal/target/CC2530NB/: hal_adc.c hal_buzzer.c hal_dma.c hal_flash.c hal_key.c hal_keypad.c hal_lcd.c hal_led.c hal_rs485.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2530NB/Includes
    ../../../../../Components/hal/target/CC2530NB/: hal_aes.h hal_dma.h hal_mcu.h hal_types.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_DEBUG.c MT_DEBUG.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    ../../../../../Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../../Components/osal/mcu/cc2530/: OSAL_Nv.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_general.c zcl_general.h
    ../../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2530DB/: f8w2530.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2530DB/: chipcon_cstartup.s51 OnBoard.c onboard.h ZMain.c
